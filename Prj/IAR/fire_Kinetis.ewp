# IAR project fire_Kinetis.ewp, settings and files
configuration FX15_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60FX512xxx15 Freescale MK60FX512xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: IAR; DEBUG; ARM_MATH_CM4; MK60F15
  ICCARM.CCIncludePath2: ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fire_Kinetis.hex
  ILINK.IlinkOutputFile: fire_Kinetis.out
  ILINK.IlinkIcfFile: config files\fire_ROM_K60N512.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FX15_Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG; IAR; ARM_MATH_CM4; MK60F15
  ICCARM.CCOptLevel: 3
configuration DZ10_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: IAR; DEBUG; ARM_MATH_CM4; MK60DZ10
configuration DZ10_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG; IAR; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCOptLevel: 3
  group App
    ../../App/: control.c control.h main.c MK60_it.c
  group Board
    ../../Board/src/: FIRE_ASCII.c FIRE_BMP.c fire_img2sd.c FIRE_key.c FIRE_key_event.c FIRE_LCD.c FIRE_LCD_CH.c FIRE_LCD_ILI9341.c FIRE_LCD_ST7735R.c FIRE_LCD_ST7735S.c FIRE_LED.C FIRE_MK60_conf.c FIRE_MMA7455.c FIRE_NRF24L0.c FIRE_NRF24L0_MSG.c FIRE_OV7725_Eagle.c FIRE_OV7725_Wolf.c FIRE_RTC_count.C FIRE_SCCB.c fire_sd_app.c FIRE_TSL1401.c FIRE_UI_VAR.c
    ../../Board/inc/: FIRE_MK60_conf.h
  group Chip
    ../../Chip/inc/: common.h
    ../../Chip/src/: misc.c MK60_adc.c MK60_can.c MK60_dac.c MK60_dma.c MK60_DWT.c MK60_flash.c MK60_flexbus.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_rtc.c MK60_sdhc.c MK60_spi.c MK60_SysTick.c MK60_uart.c MK60_usb.c MK60_wdog.c vectors.c
    ../../Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
  group LIB/CMSIS
    ../../Lib/CMSIS/: iar_cortexM4l_math.a
  group LIB/FatFs
    ../../Lib/FatFs/: diskio.c ff.c
  group LIB/USB
    ../../Lib/USB/: USB.c USB_CDC.c
